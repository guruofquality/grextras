<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dual_mac_loop_back</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>S</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>a</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>label</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>no_arq_port</value></param>
<param><key>value</key><value>12345</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_addr</value></param>
<param><key>value</key><value>85</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arq_port</value></param>
<param><key>value</key><value>12346</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arq_timeout</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0</value></param>
<param><key>period</key><value>0.001</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0_1</value></param>
<param><key>period</key><value>0.001</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0_0</value></param>
<param><key>period</key><value>2</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value>this is a test beacon</value></param>
</block>
<block>
<key>virtual_channel_formatter</key>
<param><key>id</key><value>virtual_channel_formatter_0</value></param>
<param><key>channel</key><value>86</value></param>
<param><key>arq</key><value>1</value></param>
</block>
<block>
<key>simple_mac</key>
<param><key>id</key><value>simple_mac_0_0</value></param>
<param><key>addr</key><value>85</value></param>
<param><key>maximum_attempts</key><value>10</value></param>
<param><key>timeout</key><value>arq_timeout</value></param>
</block>
<block>
<key>simple_mac</key>
<param><key>id</key><value>simple_mac_0</value></param>
<param><key>addr</key><value>86</value></param>
<param><key>maximum_attempts</key><value>10</value></param>
<param><key>timeout</key><value>arq_timeout</value></param>
</block>
<block>
<key>msg_to_stdout</key>
<param><key>id</key><value>msg_to_stdout_0</value></param>
</block>
<block>
<key>virtual_channel_formatter</key>
<param><key>id</key><value>virtual_channel_formatter_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>channel</key><value>85</value></param>
<param><key>arq</key><value>1</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>period</key><value>2</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value>this is a test beacon</value></param>
</block>
<connection><source_block_id>virtual_channel_formatter_0_0</source_block_id><sink_block_id>simple_mac_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_channel_formatter_0</source_block_id><sink_block_id>simple_mac_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>heart_beat_0</source_block_id><sink_block_id>simple_mac_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>simple_mac_0</source_block_id><sink_block_id>simple_mac_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>heart_beat_0_1</source_block_id><sink_block_id>simple_mac_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>heart_beat_0_0</source_block_id><sink_block_id>virtual_channel_formatter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simple_mac_0</source_block_id><sink_block_id>msg_to_stdout_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simple_mac_0_0</source_block_id><sink_block_id>simple_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>heart_beat_0_0_0</source_block_id><sink_block_id>virtual_channel_formatter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
