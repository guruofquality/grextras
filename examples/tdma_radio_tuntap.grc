<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tdma_radio_tuntap</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>output_port</value></param>
<param><key>value</key><value>12347</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>a</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_addr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>S</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>label</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>input_port</value></param>
<param><key>value</key><value>12345</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_arq_attempts</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>guard_interval</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arq_timeout</value></param>
<param><key>value</key><value>.10</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clk_src</value></param>
<param><key>value</key><value>Default</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>key_string</value></param>
<param><key>value</key><value>UV</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_slots</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>slot_interval</value></param>
<param><key>value</key><value>0.010</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_slot</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dest_addr</value></param>
<param><key>value</key><value>86</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lead_limit</value></param>
<param><key>value</key><value>0.025</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hb_rate</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>msg_rate</value></param>
<param><key>value</key><value>1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>device</value></param>
<param><key>value</key><value>Automatic</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>simple_mac</key>
<param><key>id</key><value>simple_mac_0</value></param>
<param><key>addr</key><value>radio_addr</value></param>
<param><key>maximum_attempts</key><value>max_arq_attempts</value></param>
<param><key>timeout</key><value>arq_timeout</value></param>
</block>
<block>
<key>virtual_channel_formatter</key>
<param><key>id</key><value>virtual_channel_formatter_0</value></param>
<param><key>channel</key><value>dest_addr</value></param>
<param><key>arq</key><value>1</value></param>
</block>
<block>
<key>extras_tuntap</key>
<param><key>id</key><value>extras_tuntap_0</value></param>
<param><key>dev</key><value></value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0</value></param>
<param><key>period</key><value>0.001</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>tdma_hier</key>
<param><key>id</key><value>tdma_hier_0</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>samp_per_sym</key><value>samp_per_sym</value></param>
<param><key>args</key><value>args</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>ampl</key><value>ampl</value></param>
<param><key>tx_gain</key><value>tx_gain</value></param>
<param><key>number_of_slots</key><value>num_slots</value></param>
<param><key>lead_limit</key><value>lead_limit</value></param>
<param><key>initial_slot</key><value>initial_slot</value></param>
<param><key>link_speed</key><value>rate/samp_per_sym</value></param>
<param><key>slot_interval</key><value>slot_interval</value></param>
<param><key>guard_interval</key><value>guard_interval</value></param>
</block>
<block>
<key>gr_nop</key>
<param><key>id</key><value>gr_nop_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_null_source</key>
<param><key>id</key><value>gr_null_source_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>heart_beat_0</source_block_id><sink_block_id>simple_mac_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>simple_mac_0</source_block_id><sink_block_id>tdma_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_channel_formatter_0</source_block_id><sink_block_id>simple_mac_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>extras_tuntap_0</source_block_id><sink_block_id>virtual_channel_formatter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>simple_mac_0</source_block_id><sink_block_id>extras_tuntap_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tdma_hier_0</source_block_id><sink_block_id>simple_mac_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tdma_hier_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_null_source_0</source_block_id><sink_block_id>gr_nop_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_nop_0</source_block_id><sink_block_id>tdma_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
