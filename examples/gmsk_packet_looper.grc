<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>tx_digital_gain</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0.3</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>1.1e9</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>extras_noise_source</key>
<param><key>id</key><value>extras_noise_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>wave</key><value>GAUSSIAN</value></param>
<param><key>seed</key><value>-42</value></param>
<param><key>off</key><value>0</value></param>
<param><key>scalar</key><value>0.01</value></param>
<param><key>factor</key><value>9.0</value></param>
</block>
<block>
<key>extras_signal_source</key>
<param><key>id</key><value>extras_signal_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>wave</key><value>COSINE</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>wave_freq</key><value>samp_rate/10.12345</value></param>
<param><key>off</key><value>0</value></param>
<param><key>scalar</key><value>0.3</value></param>
</block>
<block>
<key>extras_packet_framer</key>
<param><key>id</key><value>extras_packet_framer_0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>access_code</key><value></value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bt</key><value>0.35</value></param>
</block>
<block>
<key>extras_burst_tagger</key>
<param><key>id</key><value>extras_burst_tagger_0</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>extras_multiply_const</key>
<param><key>id</key><value>extras_multiply_const_0</value></param>
<param><key>type</key><value>fc32_fc32</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>value</key><value>tx_digital_gain</value></param>
</block>
<block>
<key>extras_packet_deframer</key>
<param><key>id</key><value>extras_packet_deframer_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>extras_datagram_to_stream</key>
<param><key>id</key><value>extras_datagram_to_stream_0</value></param>
<param><key>item_size</key><value>8</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate/20</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>extras_add</key>
<param><key>id</key><value>extras_add_0</value></param>
<param><key>type</key><value>fc32_fc32</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>extras_stream_to_datagram</key>
<param><key>id</key><value>extras_stream_to_datagram_0</value></param>
<param><key>item_size</key><value>8</value></param>
<param><key>mtu</key><value>256</value></param>
</block>
<connection><source_block_id>extras_packet_framer_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>extras_burst_tagger_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>extras_packet_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_packet_deframer_0</source_block_id><sink_block_id>extras_datagram_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_stream_to_datagram_0</source_block_id><sink_block_id>extras_packet_framer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_signal_source_0</source_block_id><sink_block_id>extras_add_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_noise_source_0</source_block_id><sink_block_id>extras_add_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>extras_datagram_to_stream_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_multiply_const_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_burst_tagger_0</source_block_id><sink_block_id>extras_multiply_const_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_add_0</source_block_id><sink_block_id>extras_stream_to_datagram_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
